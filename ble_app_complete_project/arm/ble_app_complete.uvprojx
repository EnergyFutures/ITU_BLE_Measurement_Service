# Keil uVision project ble_app_complete.uvprojx, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_template +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\sd_common
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group ::Device
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
    RTE/Device/nRF51822_xxAB/: arm_startup_nrf51.s system_nrf51.c
  group Source Code
    ./../: main.c
    ../: main.h mote_config.h sensor_service.c simple_actuator_service.c read_all_sensor_service.c read_all_sensor_service.h twi_master_int.c twi_master_int.h pstorage_platform.h window_actuator.c window_actuator.h ac_actuator.c ac_actuator.h ac_actuator_config.h window_actuator_config.h HT_sensor_SI7021.c HT_sensor_SI7021.h HT_sensor_SI7021_config.h light_sensor_TSL2561.c light_sensor_TSL2561.h light_sensor_TSL2561_config.h temp_sensor_tmp36.c temp_sensor_tmp36.h temp_sensor_tmp36_config.h
  group Services
    ../../../../../Source/ble/ble_services/: ble_srv_common.c ble_dis.c
  group Libraries
    ../../../../../Source/ble/: ble_error_log.c ble_advdata.c ble_conn_params.c ble_debug_assert_handler.c
    ../../../../../Source/app_common/: pstorage.c crc16.c app_scheduler.c app_timer.c app_button.c app_gpiote.c
    ../../../../../Source/sd_common/: softdevice_handler.c
    ../../../../../Source/nrf_delay/: nrf_delay.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: as above
  output: ble_app_template +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310
  c include: as above
  memory RVCT4: ROM 0x16000 size 0x9000
  memory RVCT9: RAM 0x20002000 size 0x2000
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.1
